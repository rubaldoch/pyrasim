options:
  parameters:
    author: Roosevelt Ubaldo based on previous implementations
    description: Generates a CW signal, TX and RX thorugh USRP, and send by ZMQ server to posprocessing.
    generate_options: no_gui
    id: sfcw_signal_generator_simul
    output_language: python
    run_options: run
    title: SFCW Signal Generator
  states: {}

blocks:
- name: baseband_freq
  id: variable
  parameters:
    value: 1e3
  states: {}
- name: light_speed
  id: variable
  parameters:
    value: 2.998e3
  states: {}
- name: loss
  id: variable
  parameters:
    value: '0.01'
  states: {}
- name: n_channels
  id: variable
  parameters:
    value: '2'
  states: {}
- name: n_points
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: noise_amp
  id: variable
  parameters:
    value: '0'
  states: {}
- name: rcs
  id: variable
  parameters:
    value: math.pi
  states: {}
- name: rx_gain
  id: variable
  parameters:
    value: '10'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 200e3
  states: {}
- name: target_range
  id: variable
  parameters:
    value: '1'
  states: {}
- name: target_speed
  id: variable
  parameters:
    value: '0'
  states: {}
- name: timestamp
  id: variable
  parameters:
    value: '1'
  states: {}
- name: tx_gain
  id: variable
  parameters:
    value: '10'
  states: {}
- name: wave_length
  id: variable
  parameters:
    value: (light_speed/baseband_freq)
  states: {}
- name: wave_type
  id: variable
  parameters:
    value: '1'
  states: {}
- name: xmlrpc_server_port
  id: variable
  parameters:
    value: '8080'
  states: {}
- name: zmq_server_port
  id: variable
  parameters:
    value: '8082'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: rcs*(tx_gain*rx_gain*pow(wave_length,2)*loss)/(pow(4*math.pi,3)*pow(target_range,4))
    type: complex
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: noise_amp
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: baseband_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_CONST_WAVE
  states: {}
- name: analog_sig_source_x_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: baseband_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: int(samp_rate*2*(target_range -target_speed*timestamp)/light_speed)
    type: complex
  states: {}
- name: blocks_interleave_0
  id: blocks_interleave
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_selector_0_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: wave_type
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: n_channels*n_points
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: xmlrpc_server_0_0
  id: xmlrpc_server
  parameters:
    addr: 127.0.0.1
    port: xmlrpc_server_port
  states: {}
- name: zeromq_pub_sink_0_0
  id: zeromq_pub_sink
  parameters:
    address: f"tcp://127.0.0.1:{zmq_server_port}"
    timeout: '100'
    type: complex
    vlen: n_channels*n_points
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_sig_source_x_0_0, '0', blocks_throttle_0, '0']
- [analog_sig_source_x_0_0_0, '0', blocks_throttle_0_0, '0']
- [blocks_add_xx_0, '0', blocks_multiply_xx_0, '0']
- [blocks_delay_0, '0', blocks_interleave_0, '1']
- [blocks_interleave_0, '0', blocks_stream_to_vector_0_0, '0']
- [blocks_multiply_xx_0, '0', blocks_delay_0, '0']
- [blocks_selector_0_0, '0', blocks_add_xx_0, '0']
- [blocks_selector_0_0, '0', blocks_interleave_0, '0']
- [blocks_stream_to_vector_0_0, '0', zeromq_pub_sink_0_0, '0']
- [blocks_throttle_0, '0', blocks_selector_0_0, '0']
- [blocks_throttle_0_0, '0', blocks_selector_0_0, '1']

metadata:
  file_format: 1
